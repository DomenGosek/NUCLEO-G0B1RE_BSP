# Keil uVision project Platform.uvprojx, settings and files
target NUCLEO-G0B1RE (6190000::V6.19::ARMCLANG)
  device: STM32G0B1RETx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00024000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: image
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Board_IO
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  scatter file: .\stm32g071.sct
  group App
    ./: Platform.c
  group Board IO
    ./Board_IO/: arduino.c arduino.h retarget_stdio.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32G0B1RETx/STCubeGenerated/Src/: main.c stm32g0xx_it.c
    ./RTE/Device/STM32G0B1RETx/STCubeGenerated/Inc/: stm32g0xx_it.h
  group STM32CubeMX
    ./RTE/Device/STM32G0B1RETx/STCubeGenerated/: STCubeGenerated.ioc
  group Documentation
    ./: README.md
software components: CMSIS-Compiler:I/O:STDERR 1.0.0, CMSIS-Compiler:I/O:STDIN 1.0.0, CMSIS-Compiler:I/O:STDOUT 1.0.0, CMSIS-Compiler:I/O:TTY 1.0.0, CMSIS-View:Event Recorder 1.5.2, CMSIS:CORE 5.7.0, CMSIS:OS Tick:SysTick 1.0.0, CMSIS:RTOS2:Keil RTX5 5.7.0, Board Support:Drivers:Basic I/O 1.0.0, CMSIS Driver:VIO:Board 2.0.0, Device:STM32Cube HAL:Common 1.4.5, Device:STM32Cube HAL:Cortex 1.4.5, Device:STM32Cube HAL:DMA 1.4.5, Device:STM32Cube HAL:GPIO 1.4.5, Device:STM32Cube HAL:PWR 1.4.5, Device:STM32Cube HAL:RCC 1.4.5, Device:STM32Cube HAL:UART 1.4.5, Device:Startup 1.6.0
